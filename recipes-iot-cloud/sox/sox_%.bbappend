
PACKAGECONFIG_append += "\
	lame \
	wavpack \
	png \
	flac \
	mad"
