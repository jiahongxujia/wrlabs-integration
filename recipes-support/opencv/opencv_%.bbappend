
PACKAGECONFIG_append += "dnn"
